<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\LQ_K60_FTM_PWM_SERVO_KEY_OLED.ewp</path>
  </project>
  <batchBuild/>
</workspace>


