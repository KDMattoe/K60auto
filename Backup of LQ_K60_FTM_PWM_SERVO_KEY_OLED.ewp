# IAR project Backup of LQ_K60_FTM_PWM_SERVO_KEY_OLED.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 NXP MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCIncludePath2: src\Includes; src\User; src\Project_Setting; src\Project_Setting\Startup; src\Project_Setting\Linker_Files; src\Libs
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LQ_K60.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: src\Project_Setting\Linker_Files\Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  OBJCOPY.OOCOutputFile: LQ_K60DN_DAC.hex
  group Driver/ADC
    src/Source/: ADC.c
    src/Includes/: ADC.h
  group Driver/common
    src/Source/: common.c
    src/Includes/: common.h
  group Driver/DAC
    src/Source/: DAC.c
    src/Includes/: DAC.h
  group Driver/DMA
    src/Source/: DMA.c
    src/Includes/: DMA.h
  group Driver/FTM
    src/Source/: FTM.c
    src/Includes/: FTM.h
  group Driver/GPIO
    src/Source/: GPIO.c
    src/Includes/: GPIO.h GPIO_Cfg.h
  group Driver/I2C
    src/Source/: I2C.c
    src/Includes/: I2C.h
  group Driver/Lptmr
    src/Source/: Lptmr.c
    src/Includes/: Lptmr.h
  group Driver/LQKEY
    src/Source/: LQKEY.c
    src/Includes/: LQKEY.h
  group Driver/LQLED
    src/Source/: LQLED.c
    src/Includes/: LQLED.h
  group Driver/PIT
    src/Source/: PIT.c
    src/Includes/: PIT.h
  group Driver/PLL
    src/Source/: PLL.c
    src/Includes/: PLL.h
  group Driver/UART
    src/Source/: UART.c
    src/Includes/: UART.h
  group Driver/Vectors
    src/Source/: vectors.c
    src/Includes/: vectors.h
  group Driver/Wdog
    src/Source/: wdog.c
    src/Includes/: wdog.h
  group Libs
    src/Libs/: MK60N512VMD100.h
  group Project_Setting/Linker_Files
    src/Project_Setting/Linker_Files/: Pflash.icf
  group Project_Setting/Startup
    src/Project_Setting/Startup/: crt0.s start.c
  group User
    src/User/: include.h LQ12864.c LQ12864.h LQMT9V034.c LQMT9V034.h main.c
